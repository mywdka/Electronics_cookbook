File: Sensors/LDR.sch (EAGLE design)
At the start: 4 parts

Commit message: Added pdf versions
Other:
- moved on the sheet: LDR, LDR1, R1, R2
